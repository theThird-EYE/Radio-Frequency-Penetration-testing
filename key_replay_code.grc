options:
  parameters:
    author: loki
    generate_options: qt_gui
    id: key_replay_code
    output_language: python
    title: Car unlock REPLAY
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/loki/key_unlock_replay
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '6'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 433.99e6
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: 433.92e6
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
