options:
  parameters:
    generate_options: qt_gui
    id: car_key_unlock
    output_language: python
    title: Car unlock capture
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 433.99e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/loki/key_unlock_replay
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    rate: .1e6
    type: complex
    wintype: window.WIN_KAISER
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_hackrf_source_0, '0', blocks_file_sink_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
